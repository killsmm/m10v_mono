DEPENDS += "camera-server estone-overlay m10v-multimedia-server"